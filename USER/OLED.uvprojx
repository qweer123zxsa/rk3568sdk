# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\NVIC;..\HARDWARE\USART2;..\HARDWARE\LED;..\HARDWARE\EXTI;..\HARDWARE\USART1;..\HARDWARE\USART3;..\HARDWARE\TIMER;..\HARDWARE\CRC16;..\HARDWARE\FOC;..\HARDWARE\IQmath;..\HARDWARE\MOTOR;..\HARDWARE\IIC;..\HARDWARE\ADC;..\HARDWARE\DMA
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_md.s
  group HARDWARE
    ./: main.c My_Define.h as56001.c
    ../HARDWARE/NVIC/: nvic.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIMER/: timer.c timer1.c
    ../HARDWARE/CRC16/: crc16.c
    ../HARDWARE/FOC/: ipark.c svpwm.c motor_control.c as5600.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/DMA/: dma2.c
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dma.c
    ../STM32F10x_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c
  group IQmath
    ../HARDWARE/IQmath/: IQmathLib.h
    ../HARDWARE/IQmath/rvmdk-cm3/: IQmathLib-cm3.lib
  group ReadMe
    ../: Readme.c
